options:
  parameters:
    author: Philipp Erhardt, based on work by Manolis Surligas, George Vardakis
    description: A NOAA APT Decoder with automatic image synchronization
    generate_options: no_gui
    id: noaa_apt_decoder
    output_language: python
    run_options: run
    title: NOAA APT Decoder
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '1'
  states: {}
- name: target_rate
  id: variable
  parameters:
    value: 4*4160*4
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: 4*4160*4
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '4'
    gain: '1'
    high_cutoff_freq: 4.2e3
    low_cutoff_freq: '500'
    samp_rate: (4*4160*4 )
    type: fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /data/recording.bin
    repeat: 'False'
    type: complex
  states: {}
- name: flip_images
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from fractions import Fraction
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import Hamlib
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: import os
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 4*4160*1.1
    decim: '1'
    gain: '1'
    samp_rate: 4*4160*4
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: ppm
  id: parameter
  parameters:
    comment: |-
      The frequency correction in PPM
      to correct for a local oscillator frequency deviation
    type: eng_float
    value: '0'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: Fraction(target_rate, int(samp_rate_rx)).limit_denominator().denominator
    interp: Fraction(target_rate, int(samp_rate_rx)).limit_denominator().numerator
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: samp_rate_rx
  id: parameter
  parameters:
    label: Device Sampling rate
    type: eng_float
    value: float(os.getenv('SAMP_RATE', '200e3'))
  states: {}
- name: satnogs_noaa_apt_sink_0
  id: satnogs_noaa_apt_sink
  parameters:
    filename_png: /output/output.png
    flip: 'False'
    height: '1800'
    sync: 'True'
    width: '2080'
  states: {}
- name: sync
  id: parameter
  parameters:
    type: intx
    value: '1'
  states: {}

connections:
- [analog_wfm_rcv_0, '0', band_pass_filter_0, '0']
- [band_pass_filter_0, '0', hilbert_fc_0, '0']
- [blocks_complex_to_mag_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_file_source_0, '0', rational_resampler_xxx_0, '0']
- [hilbert_fc_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0_0, '0']
- [rational_resampler_xxx_0_0, '0', satnogs_noaa_apt_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
