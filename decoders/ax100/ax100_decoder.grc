options:
  parameters:
    generate_options: no_gui
    generator_class_name: PythonNoGuiGenerator
    generator_module: gnuradio.grc.workflows.python_nogui
    id: ax100_decoder
    output_language: python
    run_options: run
    title: AX100 decoder
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    comment: AX100 symbol rate
    value: int(os.getenv("BAUD_RATE", 4800))
  states: {}
- name: target_sps
  id: variable
  parameters:
    comment: Target samples-per-symbol after decimation
    value: '8'
  states: {}
- name: decim
  id: variable
  parameters:
    comment: Decimation so the demod runs at ~target_sps * baud_rate
    value: max(1, int(samp_rate // (baud_rate * target_sps)))
  states: {}
- name: dec_samp_rate
  id: variable
  parameters:
    comment: Sample rate after freq_xlating_fir_filter decimation
    value: samp_rate / decim
  states: {}
- name: deviation
  id: variable
  parameters:
    comment: |-
      FSK deviation in Hz; also sets the demodulator's Carson filter
      (deviation + baud/2). AX100 satellites use ~baud/3..baud/2; 0.75*baud decoded
      the most on recorded passes. Override per satellite with DEVIATION.
    value: float(os.getenv("DEVIATION", baud_rate * 0.75))
  states: {}
- name: golay_header_len
  id: variable
  parameters:
    value: '3'
  states: {}
- name: max_frame_bits
  id: variable
  parameters:
    value: (golay_header_len + rs_coded_len) * 8
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rs_coded_len
  id: variable
  parameters:
    value: '255'
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /data/recording.bin
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: Prints decoded CSP packets to console
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '10010011000010110101000111011110'
    tagname: syncword
    threshold: '6'
    type: byte
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, baud_rate * 1.5, baud_rate * 0.75)
    type: ccc
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: import os
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Device Sampling rate
    type: eng_float
    value: float(os.getenv('SAMP_RATE', '1000e3'))
  states: {}
- name: satellites_fixedlen_to_pdu_0
  id: satellites_fixedlen_to_pdu
  parameters:
    pack: 'True'
    packet_len: max_frame_bits
    packet_len_tag_key: '"packet_len"'
    syncword_tag: syncword
    type: byte
  states: {}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: baud_rate
    iq: 'True'
    options: '"--deviation " + str(deviation)'
    samp_rate: dec_samp_rate
    subaudio: 'False'
  states: {}
- name: satellites_kiss_file_sink_0
  id: satellites_kiss_file_sink
  parameters:
    comment: KISS frames preserve per-packet boundaries
    file: /output/csp_packets.kiss
  states: {}
- name: satellites_u482c_decode_0
  id: satellites_u482c_decode
  parameters:
    rs: '1'
    scrambler: '1'
    viterbi: '0'
  states: {}

connections:
- [blocks_file_source_0_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', satellites_fixedlen_to_pdu_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', satellites_fsk_demodulator_0, '0']
- [satellites_fixedlen_to_pdu_0, pdus, satellites_u482c_decode_0, in]
- [satellites_fsk_demodulator_0, '0', digital_binary_slicer_fb_0, '0']
- [satellites_u482c_decode_0, out, blocks_message_debug_0, print]
- [satellites_u482c_decode_0, out, satellites_kiss_file_sink_0, in]

metadata:
  file_format: 1
  grc_version: gab049f6
