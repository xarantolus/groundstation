options:
  parameters:
    author: Philipp Erhardt
    generate_options: no_gui
    id: recorder
    max_nouts: 32 * 1024 * 1024
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: Generic Recorder
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: float(os.getenv('BANDWIDTH', '45e3'))
  states: {}
- name: correct_doppler
  id: variable
  parameters:
    value: os.getenv("CORRECT_DOPPLER", "").strip().lower() in ("1", "true", "yes", "on")
  states: {}
- name: frequency
  id: variable
  parameters:
    value: float(os.getenv('FREQUENCY', '145.950e6'))
  states: {}
- name: fs_capture
  id: variable
  parameters:
    value: "min(r for r in [225001,250000,256000,260000,280000,300000,320000,1024000,2048000,2400000,2560000] if r >= (samp_rate + 2*abs(lo_offset)))\r"
  states: {}
- name: gain
  id: variable
  parameters:
    value: int(os.getenv('GAIN', '-1'))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: float(os.getenv('SAMP_RATE', '1.024e6'))
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /data/recording.bin
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    comment: Shift frequency if lo_offset != 0
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: 0 if lo_offset else 1
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    comment: Output is shifted signal at samp_rate
    enabled: 'True'
    input_index: 0 if lo_offset else 1
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_0_0
  id: blocks_selector
  parameters:
    comment: Output is shifted signal at samp_rate
    enabled: 'True'
    input_index: 0 if correct_doppler else 1
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_1
  id: blocks_selector
  parameters:
    comment: Shift frequency if lo_offset != 0
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: 0 if correct_doppler else 1
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import time
      import pmt
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Tag rx_time periodically with time relative to flowgraph start
          (self._anchor captured at __init__). Lets the same doppler.txt
          correct a later replay of recording.bin without external clock
          state, since the doppler block sample-count timeline starts at 0
          in both cases.
          """

          def __init__(self, tag_interval_s=1.0):
              gr.sync_block.__init__(
                  self,
                  name="rx_time tagger",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64],
              )
              self._interval = float(tag_interval_s)
              self._anchor = time.time()
              self._last_tag_time = -float("inf")

          def work(self, input_items, output_items):
              n = len(input_items[0])
              output_items[0][:n] = input_items[0][:n]
              if n > 0:
                  now = time.time() - self._anchor
                  if now - self._last_tag_time >= self._interval:
                      full = int(now)
                      frac = now - full
                      self.add_item_tag(
                          0,
                          self.nitems_written(0) + n - 1,
                          pmt.intern("rx_time"),
                          pmt.make_tuple(pmt.from_uint64(full), pmt.from_double(frac)),
                      )
                      self._last_tag_time = now
              return n
    tag_interval_s: '1'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: lo_offset
    decim: '1'
    samp_rate: fs_capture
    taps: firdes.low_pass(1, fs_capture, bandwidth/2, bandwidth*0.2)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio.filter import firdes
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: from fractions import Fraction
  states: {}
- name: import_0_2
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import time
  states: {}
- name: lo_offset
  id: parameter
  parameters:
    type: eng_float
    value: float(os.getenv('LO_OFFSET', '100e3'))
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: fs_capture
    interp: int(samp_rate)
    type: ccc
  states: {}
- name: rtlsdr_source_0_0
  id: rtlsdr_source
  parameters:
    args: '"rtl=0,bias=1"'
    bb_gain0: '20'
    bw0: fs_capture
    freq0: frequency - lo_offset
    gain0: gain
    gain_mode0: gain < 0
    if_gain0: '20'
    sample_rate: fs_capture if lo_offset else samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: satellites_doppler_correction_0
  id: satellites_doppler_correction
  parameters:
    file: /data/doppler.txt
    samp_rate: samp_rate
    t0: '0'
    timesync_tag: '""'
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: "import logging\r\nlogging.basicConfig(\r\n    level=logging.INFO,\r\n    format='%(asctime)s - %(levelname)s - %(message)s',\r\n    datefmt='%Y-%m-%d %H:%M:%S'\r\n)\r\nlogging.info(f\"Flowgraph started with frequency={self.frequency}, bandwidth={self.bandwidth}, gain={self.gain}, sample_rate={self.samp_rate}, lo_offset={self.lo_offset}, fs_capture={self.fs_capture}\")"
    section: main_after_init
  states: {}

connections:
- [blocks_selector_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_selector_0, '1', blocks_selector_0_0, '1']
- [blocks_selector_0_0, '0', blocks_selector_0_1, '0']
- [blocks_selector_0_0_0, '0', blocks_file_sink_0, '0']
- [blocks_selector_0_1, '0', satellites_doppler_correction_0, '0']
- [blocks_selector_0_1, '1', blocks_selector_0_0_0, '1']
- [epy_block_0, '0', blocks_selector_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_selector_0_0, '0']
- [rtlsdr_source_0_0, '0', epy_block_0, '0']
- [satellites_doppler_correction_0, '0', blocks_selector_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
